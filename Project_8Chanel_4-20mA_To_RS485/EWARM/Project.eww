<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project_8Chanel_4-20mA_To_RS485.ewp</path>
  </project>
  <batchBuild />
</workspace>
